## lilygo_platypus/sdkconfig.defaults
```kconfig
CONFIG_MQTT_TRANSPORT_SSL=y
CONFIG_MQTT_TRANSPORT_WEBSOCKET=y
CONFIG_MQTT_TRANSPORT_WEBSOCKET_SECURE=y
CONFIG_MBEDTLS_CERTIFICATE_BUNDLE=y
```
